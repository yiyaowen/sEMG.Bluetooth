# Keil uVision project server.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: server
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c misc: -Wno-extra-semi-stmt -Wno-covered-switch-default -Wno-missing-noreturn -Wno-padded -Wno-cast-qual -Wno-cast-align -Wno-missing-variable-declarations -Wno-unused-parameter -Wno-newline-eof -Wno-missing-prototypes
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Server
    ./: server.c
  group Examples
    ./Examples/: common.h common.c create_task.c echo_text.c
software components: RTOS:Config 10.4.6, RTOS:Core 10.4.6, RTOS:Coroutines 10.4.6, RTOS:Event Groups 10.4.6, RTOS:Heap 10.4.6, RTOS:Message Buffer 10.4.6, RTOS:Stream Buffer 10.4.6, RTOS:Timers 10.4.6, CMSIS:CORE 5.6.0, Device:Startup 2.5.0
